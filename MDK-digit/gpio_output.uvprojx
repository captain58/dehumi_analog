# Keil uVision project gpio_output.uvprojx, settings and files
target gpio_output_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L136J8TA HDSC
  pack: HDSC.HC32L13x.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: gpio_output +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output=V0.0.67-shd30-AC.bin output\release\gpio_output.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c define: DEHUMI_DIGIT
  c include: ..\common;..\source;..\driver\inc;..\bsp;./
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l13x.s
    ../common/: interrupts_hc32l13x.c system_hc32l13x.c
  group source
    ../source/: main.c
    ../source/src/: rs485pro.c sht30.c data.c iodev.c task.c
  group driver
    ../driver/src/: ddl.c gpio.c sysctrl.c uart.c adc.c bgr.c crc.c debug.c flash.c i2c.c reset.c timer3.c wdt.c rtc.c hal_iic_sht3.c
  group bsp
    ../source/bsp/: bsp_adc_ntc.c bsp_dht11.c bsp_gpio.c bsp_pm2_5.c bsp_ringbuf.c bsp_timer.c bsp_uart.c bsp_wdt.c bsp_flash.c bsp_elecheck.c bsp_rtc.c bsp_i2c_sht3.c
software components: CMSIS:CORE 5.1.2, RTOS:kernel 3.1.5, RTOS:shell 3.1.5
